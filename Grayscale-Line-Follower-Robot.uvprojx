# Keil uVision project Grayscale-Line-Follower-Robot.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Grayscale-Line-Follower-Robot +hex
  BeforeMake: cmd.exe /C "$P.\tools\keil\syscfg.bat '$P' core\empty.syscfg"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __MSPM0G3507__
  c include: .\app;.\bsp;.\middleware;.\core;D:\ti\mspm0_sdk\source;D:\ti\mspm0_sdk\source\third_party\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\core\mspm0g3507.sct
  link misc: D:\ti\mspm0_sdk\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group app
    ./app/: main.c control.c control.h
  group bsp
    ./bsp/: board.c board.h led.c led.h oled.c oled.h oledfont.h key.c key.h motor.c motor.h encoder.c encoder.h
  group core
    ./core/: empty.syscfg startup_mspm0g350x_uvision.s ti_msp_dl_config.h ti_msp_dl_config.c
